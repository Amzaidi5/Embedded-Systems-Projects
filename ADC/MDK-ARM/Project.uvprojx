# Keil uVision project Project.uvprojx, settings and files
target STM32F429I-Discovery (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429I-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F429I-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_adc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr_ex.c
  group Drivers/BSP/STM32F429I-Discovery
    ../../../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c
software components: CMSIS:CORE 4.1.0
